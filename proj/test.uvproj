# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c include: ..\inc;..\board\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Third_Party\fat_fs\inc;..\Third_Party\myUI\inc;..\Third_Party\apps;..\Third_Party\fmanage;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group board
    ../board/src/: spi.c led.c key.c delay.c timer.c usart.c lcd.c touch.c sdio_sd.c at45db.c rtc.c mma7455.c CS4334.c mempool.c ov7670.c
  group periph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_dcmi.c
  group fat
    ../Third_Party/fat_fs/src/: fsearch.c diskio.c ff.c
  group myUI
    ../Third_Party/myUI/src/: GDGUI.c GUI_GIF.c
  group apps
    ../Third_Party/apps/: music.c ebook.c album.c camera.c fmanager.c game2.c game1.c
